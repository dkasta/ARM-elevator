# Keil uVision project sample.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sample
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup_file
    ./: startup_LPC17xx.s
  group main
    ./: sample.c common.h
  group lib_SoC_board
    ./: core_cm3.c system_LPC17xx.c
  group led
    ./led/: lib_led.c led.h
  group button_EINT
    ./button_EXINT/: button.h IRQ_button.c
  group timer
    ./timer/: IRQ_timer.c timer.h
  group RIT
    ./RIT/: lib_RIT.c RIT.h
  group joystick
    ./joystick/: joystick.h lib_joystick.c
  group elevator
    ./elevator/: elevator.c elevator.h
  group adc_dac
    ./adc_dac/: adc.c adc.h
  group GLCD
    ./GLCD/: AsciiLib.c AsciiLib.h GLCD.c GLCD.h HzLib.c HzLib.h
  group TouchPanel
    ./TouchPanel/: TouchPanel.c TouchPanel.h
software components: CMSIS:CORE 5.3.0
